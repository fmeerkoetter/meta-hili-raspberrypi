FILESEXTRAPATHS_prepend := "${THISDIR}/hardening:"
SRC_URI += "file://security.cfg"
